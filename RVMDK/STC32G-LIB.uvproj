# Keil uVision project STC32G-LIB.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: STC32G-LIB +hex
  BeforeMake: python ..\tools\gen_board_resources.py
  link misc: REMOVEUNUSED
  group Startup
    ../Startup/: isr.asm
  group Platform
    ../Platform/Src/: platform.c platform_scheduler.c
  group App
    ../App/Src/: main.c app.c ship_control.c autodrive.c autodrive_config.c ship_protocol.c
    ../App/Inc/: app_config.h ship_control.h autodrive.h autodrive_config.h ship_protocol.h
  group BoardDevices
    ../BoardDevices/Src/: board_console.c board_sensor_bus.c board_imu.c board_motor.c board_power.c board_storage.c board_mag.c board_lt8920.c board_wireless.c board_spi_ps.c board_gps.c
    ../BoardDevices/Inc/: board_imu.h board_motor.h board_power.h board_storage.h board_mag.h board_lt8920.h board_wireless.h board_gps.h
  group Components
    ../Components/Src/: PID.c Filter.c AHRS.c HeadingEstimator.c MagCompass.c
    ../Components/Inc/: PID.h Filter.h AHRS.h HeadingEstimator.h MagCompass.h
  group ChipDrivers
    ../ChipDrivers/Src/: gnss_nmea.c QMI8658.c QMC6309.c LT8920.c KCT8206.c
    ../ChipDrivers/Inc/: gnss_nmea.h QMI8658.h QMC6309.h LT8920.h KCT8206.h
  group Drivers
    ../Drivers/Src/: STC32G_ADC.c STC32G_Compare.c STC32G_Delay.c STC32G_EEPROM.c STC32G_Exti.c STC32G_GPIO.c STC32G_I2C.c STC32G_LCM.c STC32G_NVIC.c STC32G_Soft_I2C.c STC32G_Soft_UART.c STC32G_SPI.c STC32G_Timer.c STC32G_UART.c STC32G_WDT.c STC32G_DMA.c STC32G_PWM.c STC32G_RTC.c STC32G_CAN.c STC32G_LIN.c STC32G_Clock.c STC32G_USART_LIN.c
  group McuAbstraction
    ../McuAbstraction/Src/: ef_uart.c ef_iic.c ef_spi.c
    ../McuAbstraction/Inc/: ef_iic.h ef_uart.h ef_spi.h
  group Drivers_ISR
    ../Drivers/Isr/: STC32G_ADC_Isr.c STC32G_Compare_Isr.c STC32G_Exti_Isr.c STC32G_GPIO_Isr.c STC32G_I2C_Isr.c STC32G_SPI_Isr.c STC32G_Timer_Isr.c STC32G_UART_Isr.c STC32G_DMA_Isr.c STC32G_PWM_Isr.c STC32G_RTC_Isr.c STC32G_LCM_Isr.c STC32G_CAN_Isr.c STC32G_LIN_Isr.c
  group Drivers_LIB
    ../Drivers/Lib/: STC32_MDU32_HUGE.LIB STC32_MDU32_LARGE.LIB
  group Services
    ../Services/Src/: logger.c parameter_store.c
    ../Services/Inc/: parameter_store.h
